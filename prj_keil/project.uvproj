# Keil uVision project project.uvproj, settings and files
target Debug (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread-stm32f4xx
  AfterMake: fromelf --bin !L --output ..\BIN\CMS.BIN
  c flags: Optim=1 wLevel=2
  c define: ATMEL_RF,SYS_OS,SYS_OS_RTT,STM32F4XX,STM32F405xx,_COORDINATOR_,USE_STDPERIPH_DRIVER,USE_STM3210B_EVAL,NOTRACE,SIO_HUB,UART0,DEBUG=0,FFD,REDUCED_PARAM_CHECK,TAL_TYPE=AT86RF231,PAL_TYPE=AT91SAM3S4C,PAL_GENERIC_TYPE=SAM3,BOARD_TYPE=RZ600_231_SAM3SEK,HIGHEST_STACK_LAYER=MAC,NODMA_SPI,TRX_REG_RAW_VALUE,PA
  c misc: --gnu --c99
  c include: .;..\library\STM32F4xx_Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\library\STM32F4xx_Libraries\CMSIS\Include;..\library\STM32F4xx_Libraries\CMSIS\ST\STM32F4xx\Include;..\library\STM32F4xx_Libraries\STM32F4xx_StdPeriph_Driver\inc;..\library\STM32F4xx_Libraries\STM32_USB_HOST_Library\Core\inc;..\library\STM32F4xx_Libraries\STM32_USB_OTG_Driver\inc;..\applications;..\drivers;..\os\rtthread\components\drivers\include;..\os\rtthread\components\finsh;..\os\rtthread\components\init;..\os\rtthread\components\rtgui\include;..\os\rtthread\include;..\os\rtthread\libcpu\arm\common;..\include;..\os\rtthread\libcpu\arm\cortex-m4;..\drivers\zigbee\coordinator\Include;..\drivers\zigbee\coordinator\TAL\Inc;..\drivers\zigbee\coordinator\TAL\AT86RF231\Inc;..\drivers\zigbee\coordinator\PAL\Inc;..\drivers\zigbee\coordinator\PAL\SAM3\Generic\Inc;..\drivers\zigbee\coordinator\PAL\SAM3\AT91SAM3S4C\Boards;..\drivers\zigbee\coordinator\PAL\SAM3\AT91SAM3S4C\Boards\RZ600_231_SAM3SEK;..\drivers\zigbee\coordinator\PAL\SAM3\Libraries;..\drivers\zigbee\coordinator\PAL\SAM3\Libraries\usb\include;..\drivers\zigbee\coordinator\MAC\Inc;..\drivers\zigbee\coordinator\Resources\Buffer_Management\Inc;..\drivers\zigbee\coordinator\Resources\Queue_Management\Inc;..\drivers\zigbee\coordinator\NWK\Inc;..\drivers\zigbee\coordinator\NWK\atmel_Inc;..\drivers\zigbee\coordinator\Applications;..\drivers\zigbee\coordinator\Applications\Helper_Files\SIO_Support\Inc;..\drivers\zigbee\coordinator\STM32F10x_StdPeriph_Lib_V3.5.0\Project\BSP\OS\uCOS-III
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __rtmsym_*   --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group App
    ../app/cms/: cv_vsa.c cv_sys_main.c cv_sys_manager.c cv_sys_param.c cv_sys_sound_resource.c
    ../app/vam/: cv_vam_main.c cv_vam_api.c cv_vam_lip.c cv_vam_lip_nmea.c cv_vam_rcp.c cv_vam_vsm.c cv_vam_util.c
  group Drivers
    ../drivers/: cv_drv_gps.c cv_drv_gsnr.c cv_drv_msnr.c cv_drv_zmac.c cv_drv_fls.c cv_drv_voc.c cv_drv_led.c Cv_drv_key.c
  group Bsp
    ../bsp/: board.c i2c.c isr.c led.c platform.c spi.c usart.c l3gd20.c lsm303dlhc.c bma250e.c
  group Library
    ../library/STM32F4xx_Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Startup
    ../startup/: startup.c startup_stm32f4xx.s system_stm32f4xx.c
  group OS_Kernel
    ../os/rtthread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c module.c object.c scheduler.c thread.c timer.c
  group OS_Port
    ../os/rtthread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../os/rtthread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group OS_Comp_Drivers
    ../os/rtthread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../os/rtthread/components/drivers/serial/: serial.c
    ../os/rtthread/components/drivers/spi/: spi_core.c spi_dev.c
    ../os/rtthread/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c
  group OS_Comp_Finsh
    ../os/rtthread/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
    ../OS/rtthread/components/init/: components.c
  group zigbee
    ../drivers/zigbee/coordinator/Applications/: Version.c
    ../drivers/zigbee/coordinator/MAC/Src/: mac.c mac_api.c mac_callback_wrapper.c mac_data_extract_mhr.c mac_data_ind.c mac_data_req.c mac_dispatcher.c mac_mcps_data.c mac_misc.c mac_pib.c mac_process_tal_tx_frame_status.c usr_mcps_data_conf.c usr_mcps_data_ind.c usr_mlme_reset_conf.c
    ../drivers/zigbee/coordinator/NWK/Src/: ModuleID.c nwk.c nwk_api.c nwk_broadcast.c nwk_callback_wrapper.c nwk_DataReq.c nwk_dispatcher.c nwk_misc.c nwk_pib.c nwkFrame.c usr_nlde_data_conf.c usr_nlde_data_ind.c
    ../drivers/zigbee/coordinator/PAL/SAM3/Generic/Src/: pal.c pal_timer.c pal_trx_access.c
    ../drivers/zigbee/coordinator/PAL/SAM3/AT91SAM3S4C/Boards/RZ600_231_SAM3SEK/: pal_board.c pal_irq.c
    ../drivers/zigbee/coordinator/Resources/Queue_Management/Src/: qmm.c
    ../drivers/zigbee/coordinator/Resources/Buffer_Management/Src/: bmm.c
    ../drivers/zigbee/coordinator/TAL/AT86RF231/Src/: tal.c tal_init.c tal_irq_handler.c tal_pib.c tal_rx.c tal_rx_enable.c tal_tx.c Uz2400D.c
    ../drivers/zigbee/coordinator/STM32F10x_StdPeriph_Lib_V3.5.0/Project/BSP/OS/uCOS-III/: bsp_os.c
    ../drivers/zigbee/coordinator/Applications/MAC_Examples/Nobeacon_Application/Coordinator/Src/: zigbee_main.c
